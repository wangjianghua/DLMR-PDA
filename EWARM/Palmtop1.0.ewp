# IAR project Palmtop1.0.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZE ST STM32F207ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: OS_SUPPORT; USE_HAL_DRIVER; STM32F207xx
  ICCARM.CCIncludePath2: ..\APP; ..\BSP; ..\BSP\CMSIS; ..\BSP\CMSIS\Device_Support; ..\BSP\OS\uCOS-II; ..\BSP\STM32F2xx\inc; ..\uC-CPU; ..\uC-CPU\ARM-Cortex-M3\IAR; ..\uC-LIB; ..\uC-LIB\Ports\ARM-Cortex-M3\IAR; ..\uCOS-II\Source; ..\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR; ..\STemWin\inc; ..\STemWin\Config; ..\drv\Inc; ..\drv; ..\FatFs; ..\GUI
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Palmtop1.0.bin
  ILINK.IlinkOutputFile: Palmtop1.0.out
  ILINK.IlinkIcfFile: ..\BSP\IAR\stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group APP
    ../APP/: app.c APP_device.c app_hooks.c APP_Protocol.c DL645.c GDW376_2.c link_manager.c queue.c RF_App.c uart_link.c
  group BSP
    ../BSP/: bsp.c bsp_int.c
    ../BSP/IAR/: cstartup.c
  group BSP/CMSIS
    ../BSP/CMSIS/Device_Support/: system_stm32f2xx.c
  group BSP/OS
    ../BSP/OS/uCOS-II/: bsp_os.c
  group DRV
    ../drv/: Key_Drv.c rtc.c sd.c SI4438.c SI4438_Sub.c
  group DRV/SRC
    ../drv/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_can.c stm32f2xx_hal_cortex.c stm32f2xx_hal_crc.c stm32f2xx_hal_cryp.c stm32f2xx_hal_dac.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_dcmi.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_hash.c stm32f2xx_hal_hcd.c stm32f2xx_hal_i2c.c stm32f2xx_hal_i2s.c stm32f2xx_hal_irda.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_msp_template.c stm32f2xx_hal_nand.c stm32f2xx_hal_nor.c stm32f2xx_hal_pccard.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rng.c stm32f2xx_hal_rtc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_smartcard.c stm32f2xx_hal_spi.c stm32f2xx_hal_sram.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c stm32f2xx_hal_usart.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_fsmc.c stm32f2xx_ll_sdmmc.c stm32f2xx_ll_usb.c
  group FatFs
    ../FatFs/option/: cc936.c syscall.c
    ../FatFs/: diskio.c ff.c
  group GUI
    ../gui/: AboutDLG.c AdvanceSetDLG.c CommParaSetDLG.c CommStdTestDLG.c DataSignDLG.c ErrNoteDLG.c FreqSetDLG.c GUI_public_fun.c InputWidget.c MessageDLG.c MonitorDLG.c PDA_Bitmap.c PDA_IconMenuDLG.c phrase.c ReadMeterDLG.c RelayAddrDLG.c SDInfo.c SysInfoDLG.c TimeSet.c
  group GUI/FONT
    ../gui/FONT/: new_song_16.c
  group STemWin
    ../STemWin/OS/: GUI_X.c
    ../STemWin/Config/: GUIConf.c LCDConf.c
    ../STemWin/Lib/: STemWin522_CM3_OS_IAR.a
  group uC/CPU
    ../uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm cpu_c.c
    ../uC-CPU/: cpu_core.c
  group uC/LIB
    ../uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group UC/OS-II
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu_a.asm os_cpu_c.c os_dbg.c
